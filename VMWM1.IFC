Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\Producten\1. Faunavoorzieningen\1. Houten voorzieningen\XPS KASTEN\VMWM serie\2. Tekeningen en documentatie\3. Klanttekeningen\VMWM3.IFC
Time: 2025-02-10T12:57:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
